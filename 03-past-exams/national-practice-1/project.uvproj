# Keil uVision project project.uvproj, settings and files
target Practice (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;driver;user
  asm include: .;driver;user
  group Source Group 1
    ./: main.c 15f2k60s2.h iic.c iic.h onewire.c onewire.h key.c key.h ds1302.c ds1302.h
