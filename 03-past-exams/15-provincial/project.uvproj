# Keil uVision project project.uvproj, settings and files
target Practice (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(12000000) MODP2
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;driver;user
  asm include: .;driver;user
  group user
    ./user/: STARTUP.A51 main.c
  group driver
    ./driver/: Latch.c Init.c Led.c Key.c Seg.c ds1302.c iic.c
