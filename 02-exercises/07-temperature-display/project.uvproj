# Keil uVision project project.uvproj, settings and files
target Practice (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: firmware +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .;driver;user
  asm include: .;driver;user
  group Source Group 1
    ./: main.c onewire.c onewire.h smg_swj.c smg_swj.h
